# Keil uVision project KEILC.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: KEILC +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ../Lib/: delay.c delay.h DHT11.c DHT11.h LCD_1602.c LCD_1602.h UART_Mode1.c UART_Mode1.h beep.c beep.h SoilMoisture.c SoilMoisture.h WaterLevel.c WaterLevel.h
